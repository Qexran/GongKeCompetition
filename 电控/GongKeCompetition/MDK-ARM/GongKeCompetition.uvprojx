# Keil uVision project GongKeCompetition.uvprojx, settings and files
target GongKeCompetition (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: GongKeCompetition +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --locale=C --diag_suppress=870
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../ThirdParty/FreeRTOS-Kernel/include;../ThirdParty/FreeRTOS-Kernel/portable/RVDS/ARM_CM4F;../Drivers/QEPack;../Application
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: freertos.c OLED.c OLED_Data.c main.c gpio.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group ThirdParty/FreeRTOS-Kernel
    ../ThirdParty/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../ThirdParty/FreeRTOS-Kernel/portable/RVDS/ARM_CM4F/: port.c
    ../ThirdParty/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
  group Drivers/QEPack
    ../Drivers/QEPack/: servo_device.c key_device.c uart_device.c emm_v5_device.c atk_ms901m_device.c gyro_m0_device.c
  group Application
    ../Application/: app_main.c app_uart.c app_key.c app_oled.c app_oled_menu.c app_arm.c app_motor.c app_sensors.c app_comm.c app_bt.c app_actuator.c app_tick.c app_beam.c app_chassis.c app_chassis_action.c app_pid.c app_transfer.c app_script.c map.c app_arm_action.c app_cali.c app_rpi.c app_line.c app_config.h
    ../Core/Inc/: project_config.h
software components: CMSIS:CORE 4.3.0
